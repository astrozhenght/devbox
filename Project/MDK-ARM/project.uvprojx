# Keil uVision project project.uvprojx, settings and files
target project (6190000::V6.19::ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,USE_FULL_LL_DRIVER,STM32H743xx
  c include: ..\..\App\Config;..\..\App\LVGL;..\..\App\LVGL\assets\fonts;..\..\App\LVGL\assets\images;..\..\App\Service;..\..\App\Tasks;..\..\BSP\Inc;..\..\Common\Inc;..\..\Platform\MCU\Core\Inc;..\..\Platform\MCU\User\Inc;..\..\Platform\Port\CMSIS-DAP;..\..\Platform\Port\FatFS;..\..\Platform\Port\FreeRTOS;..\..\Platform\Port\LVGL;..\..\Platform\Port\USB;..\..\ThirdParty\cJSON;..\..\ThirdParty\CMSIS-DAP\Firmware\Include;..\..\ThirdParty\FatFS\source;..\..\ThirdParty\FreeRTOS\Source\include;..\..\ThirdParty\LVGL\src\core;..\..\ThirdParty\LVGL\src\draw;..\..\ThirdParty\LVGL\src\extra;..\..\ThirdParty\LVGL\src\font;..\..\ThirdParty\LVGL\src\hal;..\..\ThirdParty\LVGL\src\misc;..\..\ThirdParty\LVGL\src\widgets;..\..\ThirdParty\LVGL\src\;..\..\ThirdParty\LVGL\;..\..\ThirdParty\STM32_USB_Device_Library\Core\Inc;..\..\ThirdParty\ST\CMSIS\Device\ST\STM32H7xx\Include;..\..\ThirdParty\ST\CMSIS\Include;..\..\ThirdParty\ST\STM32H7xx_HAL_Driver\Inc;..\..\ThirdParty\ST\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x24000000 size 0x80000
  scatter file: .\project.sct
  group App/LVGL
    ../../App/LVGL/: ui_file_manager.c ui_home.c ui_uart_terminal.c ui_calendar.c ui_weather.c ui_calculator.c ui_daplink.c ui_pc_monitor.c
  group App/LVGL/assets
    ../../App/LVGL/assets/fonts/: ui_font_chinese_12_1.c ui_font_chinese_20.c ui_font_chinese_24_4.c ui_font_chinese_32_4.c ui_font_chinese_48_1.c ui_font_chinese_60_4.c ui_font_chinese_72_4.c
    ../../App/LVGL/assets/images/: ui_images.c ui_img_icon_calendar.c ui_img_icon_calculator.c ui_img_icon_daplink.c ui_img_icon_filemanager.c ui_img_icon_folder48.c ui_img_icon_file32.c ui_img_icon_monitor.c ui_img_icon_music.c ui_img_icon_setting.c ui_img_icon_uart.c ui_img_icon_weather.c ui_img_weather_0.c ui_img_weather_1.c ui_img_weather_2.c ui_img_weather_3.c ui_img_weather_4.c ui_img_weather_5.c ui_img_weather_6.c ui_img_weather_7.c ui_img_weather_8.c ui_img_weather_9.c ui_img_weather_10.c ui_img_weather_11.c ui_img_weather_12.c ui_img_weather_13.c ui_img_weather_14.c ui_img_weather_15.c ui_img_weather_16.c ui_img_weather_17.c ui_img_weather_18.c ui_img_weather_19.c ui_img_weather_20.c ui_img_weather_21.c ui_img_weather_22.c ui_img_weather_23.c ui_img_weather_24.c ui_img_weather_25.c ui_img_weather_26.c ui_img_weather_27.c ui_img_weather_28.c ui_img_weather_29.c ui_img_weather_30.c ui_img_weather_31.c ui_img_weather_32.c ui_img_weather_33.c ui_img_weather_34.c ui_img_weather_35.c ui_img_weather_36.c ui_img_weather_37.c ui_img_weather_38.c ui_img_weather_99.c
    ../../ThirdParty/LVGL/src/font/: lv_font_montserrat_16.c lv_font_montserrat_22.c
  group App/Service
    ../../App/Service/: file_service.c file_service_fatfs.c uart_service.c uart_service_stm32.c wifi_service_stm32.c weather_service.c weather_service_seniverse.c weather_http.c calculator_service.c system_monitor.c pc_monitor_service.c dap_service.c dap_programmer.c firmware_reader.c flm_parser.c flm_executor.c target_profile.c
  group App/Tasks
    ../../App/Tasks/: file_task.c app_tasks.c ui_task.c wifi_task.c dap_task.c pc_monitor_task.c
  group BSP
    ../../BSP/Src/: bsp_board.c bsp_flash.c bsp_lcd.c bsp_rtc.c bsp_sd.c bsp_touch.c bsp_wifi.c bsp_dap.c
  group Common
    ../../Common/Src/: hex_convert.c ring_buffer.c lunar_calendar.c
  group Platform/MCU/Core
    ../../Platform/MCU/Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
    ./: startup_stm32h743xx.s
  group Platform/MCU/User
    ../../Platform/MCU/User/Src/: dma.c dma2d.c gpio.c i2c.c image.c ltdc.c platform_mcu.c runtime_stats.c qspi.c rtc.c sdmmc.c sdram.c usart.c
  group Platform/Port/FreeRTOS
    ../../Platform/Port/FreeRTOS/: stm32h7xx_hal_timebase_tim.c
    ../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Platform/Port/LVGL
    ../../Platform/Port/LVGL/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group Platform/Port/FatFS
    ../../Platform/Port/FatFS/: fatfs_memory.c diskio.c ff_gen_drv.c sd_diskio_dma.c
  group Platform/Port/USB
    ../../Platform/Port/USB/: usbd_conf.c usbd_desc.c usbd_dap.c
  group ThirdParty/STM32 USB Device
    ../../ThirdParty/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group ThirdParty/CMSIS-DAP
    ../../ThirdParty/CMSIS-DAP/Firmware/Source/: DAP.c DAP_vendor.c SW_DP.c
    ../../Platform/Port/CMSIS-DAP/: swd_target.c
  group ThirdParty/ST
    ../../ThirdParty/ST/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_smbus_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c
  group ThirdParty/FreeRTOS
    ../../ThirdParty/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group ThirdParty/LVGL
    ../../ThirdParty/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../ThirdParty/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../ThirdParty/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../ThirdParty/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../ThirdParty/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../../ThirdParty/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../../ThirdParty/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../../ThirdParty/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../ThirdParty/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../../ThirdParty/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c
    ../../ThirdParty/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../ThirdParty/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../../ThirdParty/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../ThirdParty/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../../ThirdParty/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../ThirdParty/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../ThirdParty/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../../ThirdParty/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../../ThirdParty/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../../ThirdParty/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../../ThirdParty/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../ThirdParty/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../../ThirdParty/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../ThirdParty/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../ThirdParty/LVGL/src/extra/widgets/led/: lv_led.c
    ../../ThirdParty/LVGL/src/extra/widgets/list/: lv_list.c
    ../../ThirdParty/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../../ThirdParty/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../../ThirdParty/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../ThirdParty/LVGL/src/extra/widgets/span/: lv_span.c
    ../../ThirdParty/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../ThirdParty/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../../ThirdParty/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../../ThirdParty/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../../ThirdParty/LVGL/src/extra/widgets/win/: lv_win.c
    ../../ThirdParty/LVGL/src/extra/: lv_extra.c
    ../../ThirdParty/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../ThirdParty/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../ThirdParty/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../ThirdParty/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_unscii_8.c lv_font_unscii_16.c
  group ThirdParty/FatFS
    ../../ThirdParty/FatFS/source/: ff.c ffunicode.c
  group ThirdParty/cJSON
    ../../ThirdParty/cJSON/: cJSON.c
software components: CMSIS:CORE 5.6.0
